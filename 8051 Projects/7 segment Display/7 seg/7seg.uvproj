# Keil uVision project 7seg.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 Philips
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: 7seg +hex
  c flags: Optimize=8 SizeSpeed=1
